# Keil uVision project K66DEMO.uvprojx, settings and files
target K66DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FX1M0xxx18 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: K66DEMO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG,CPU_MK66FX1M0VLQ18, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FRDM_K66F, FREEDOM
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ..\Board;..\CMSIS\Driver\Include;..\CMSIS\Include;..\CMSIS\Driver\DriverTemplates;..\Component-lists;..\Component-serial_manager;..\Component-uart;..\DEVICE;..\DRIVER;..\Hardward;..\User;..\Utulitues;..\Utulitues\debug_console;..\Utulitues\str;..\DRIVER\drivers
  asm define: CPU_MK66FX1M0VLQ18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\Utulitues\MK66FX1M0xxx18_flash.scf
  link misc: --remove
  group Board
    ../Board/: board.c clock_config.c peripherals.c pin_mux.c
  group Drivers
    ../DRIVER/drivers/: fsl_smc.c fsl_lpuart.c fsl_uart.c fsl_common.c fsl_ftfx_flexnvm.c fsl_ftfx_flash.c fsl_ftfx_controller.c fsl_ftfx_cache.c fsl_clock.c fsl_gpio.c
  group Device
    ../DEVICE/: system_MK66F18.c
  group Utilties
    ../Utulitues/debug_console/: fsl_debug_console.c
    ../Utulitues/str/: fsl_str.c
    ../Utulitues/: fsl_assert.c
  group Component-uart
    ../Component-uart/: uart_adapter.c
  group Component-serial_manager
    ../Component-serial_manager/: serial_manager.c serial_port_uart.c serial_port_usb.c
  group Component-lists
    ../Component-lists/: generic_list.c
  group Starup
    ../STARUP/: startup_MK66F18.s
  group User
    ../User/: main.c
